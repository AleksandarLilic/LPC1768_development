# Keil uVision project das_v0_1.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: das_v0_1
  AfterMake: fromelf --bin -o E:\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c
  group Drivers
    ./Drivers/: bme280.c lpc1768_adc.c lpc1768_uart.c SPI_transfer_BME280.c lpc1768_gpio.c lpc1768_led.c lpc1768_timer.c lpc1768_spi.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
