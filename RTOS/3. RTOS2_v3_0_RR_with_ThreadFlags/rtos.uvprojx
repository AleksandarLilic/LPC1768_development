# Keil uVision project rtos.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtos_v3_0
  AfterMake: fromelf --bin -o E:\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c Thread1.c Thread2.c Thread3.c Thread4.c
software components: CMSIS:CORE 5.0.0, CMSIS:RTOS2:Keil RTX5 5.0.0, Compiler:Event Recorder 1.1.0, Device:Startup 1.0.0
